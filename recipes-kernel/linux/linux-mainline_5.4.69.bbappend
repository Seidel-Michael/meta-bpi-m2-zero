FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Enable-SPI-Dev.patch file://0002-Add-SPI-1-Dev.patch file://0003-Add-SPI-aliases.patch"

